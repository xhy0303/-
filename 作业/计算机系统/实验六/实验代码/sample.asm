	.ORIG x2000
POLL	LDI  R0, KBSR	 
	BRzp POLL 
	LDI  R0, KBDR
	ST R0,SAVR0
	AND R1,R1,#0
	ADD R1,R1,#10
POLL2	LD R0,SAVR0	
	STI R0,DDR
	LD R0,SIGN
	STI R0,DSR
	ADD R1,R1,#-1
	BRp POLL2
	LD R0,ENTER
	STI R0,DDR
	LD R0,SIGN
	STI R0,DSR
	RTI
ENTER	.FILL x0A
SIGN	.FILL xFFFF
SAVR0	.BLKW 1
KBSR	.FILL xFE00
KBDR	.FILL xFE02
DSR	.FILL xFE04
DDR	.FILL xFE06
	.END